# Repository italicsjenga/splitspace60

## KiCad design splitspace.kicad_pcb

Parts:
C1, C3: 10pF; C_0603_HandSoldering
C2, C7: 1uF; C_0603_HandSoldering
C4, C5, C6, C8: 0.1uF; C_0603_HandSoldering
D1: LED; LED_1206
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66: D; SOD-323
P1: USB_OTG; USB_Mini-B
P2: CONN_01X02; Pin_Header_Straight_1x02_Pitch2.54mm
R1: 100k; R_0603_HandSoldering
R2, R3: 22; R_0603_HandSoldering
R4: 200; R_0603_HandSoldering
SW1: SW_RESET; SW_SPST_FSMSM
SW2: SW_ESC; CHERRY_PCB_100H
SW3: SW_TAB; CHERRY_PCB_150H
SW4: SW_CAPS; CHERRY_PCB_175H
SW5: SW_LSHIFT; CHERRY_PCB_225H
SW6: SW_LCTRL; CHERRY_PCB_125H
SW7: SW_1; CHERRY_PCB_100H
SW8: SW_Q; CHERRY_PCB_100H
SW9: SW_A; CHERRY_PCB_100H
SW10: SW_Z; CHERRY_PCB_100H
SW11: SW_LSUP; CHERRY_PCB_125H
SW12: SW_2; CHERRY_PCB_100H
SW13: SW_W; CHERRY_PCB_100H
SW14: SW_S; CHERRY_PCB_100H
SW15: SW_X; CHERRY_PCB_100H
SW16: SW_LALT; CHERRY_PCB_125H
SW17: SW_F2; CHERRY_PCB_100H
SW18: SW_3; CHERRY_PCB_100H
SW19: SW_E; CHERRY_PCB_100H
SW20: SW_D; CHERRY_PCB_100H
SW21: SW_C; CHERRY_PCB_100H
SW22: SW_4; CHERRY_PCB_100H
SW23: SW_R; CHERRY_PCB_100H
SW24: SW_F; CHERRY_PCB_100H
SW25: SW_V; CHERRY_PCB_100H
SW26: SW_F4; CHERRY_PCB_275H
SW27: SW_5; CHERRY_PCB_100H
SW28: SW_T; CHERRY_PCB_100H
SW29: SW_G; CHERRY_PCB_100H
SW30: SW_B; CHERRY_PCB_100H
SW31: SW_SPACE; CHERRY_PCB_275H
SW32: SW_6; CHERRY_PCB_100H
SW33: SW_Y; CHERRY_PCB_100H
SW34: SW_H; CHERRY_PCB_100H
SW35: SW_N; CHERRY_PCB_100H
SW36: SW_F3; CHERRY_PCB_100H
SW37: SW_7; CHERRY_PCB_100H
SW38: SW_U; CHERRY_PCB_100H
SW39: SW_J; CHERRY_PCB_100H
SW40: SW_M; CHERRY_PCB_100H
SW41: SW_RALT; CHERRY_PCB_125H
SW42: SW_8; CHERRY_PCB_100H
SW43: SW_I; CHERRY_PCB_100H
SW44: SW_K; CHERRY_PCB_100H
SW45: SW_COMMA; CHERRY_PCB_100H
SW46: SW_RSUP; CHERRY_PCB_125H
SW47: SW_9; CHERRY_PCB_100H
SW48: SW_O; CHERRY_PCB_100H
SW49: SW_L; CHERRY_PCB_100H
SW50: SW_FSTOP; CHERRY_PCB_100H
SW51: SW_RCTRL; CHERRY_PCB_125H
SW52: SW_0; CHERRY_PCB_100H
SW53: SW_P; CHERRY_PCB_100H
SW54: SW_COLON; CHERRY_PCB_100H
SW55: SW_FSLASH; CHERRY_PCB_100H
SW56: SW_MINUS; CHERRY_PCB_100H
SW57: SW_BRKL; CHERRY_PCB_100H
SW58: SW_QUOTE; CHERRY_PCB_100H
SW59: SW_RSHIFT; CHERRY_PCB_275H
SW60: SW_PLUS; CHERRY_PCB_100H
SW61: SW_BRKR; CHERRY_PCB_100H
SW62: SW_ENTER; CHERRY_PCB_225H
SW63: SW_F1; CHERRY_PCB_100H
SW64: SW_BKSP1; CHERRY_PCB_100H
SW65: SW_BKSP2; CHERRY_PCB_100H
SW66: SW_BKSLASH; CHERRY_PCB_100H
SW67: SW_LCTRL2; CHERRY_PCB_150H
SW68: SW_LSUP2; CHERRY_PCB_100H
SW69: SW_LALT2; CHERRY_PCB_150H
SW70: SW_SPACE2; CHERRY_PCB_625H
SW71: SW_SPACE3; CHERRY_PCB_700H
SW72: SW_F32; CHERRY_PCB_125H
SW73: SW_RALT2; CHERRY_PCB_150H
SW74: SW_RSUP2; CHERRY_PCB_100H
SW75: SW_RCTRL2; CHERRY_PCB_150H
SW76: SW_RSHIFT2; CHERRY_PCB_175H
SW77: SW_BKSP22; CHERRY_PCB_200H
U1: ATmega32U4; TQFP-44_10x10mm_Pitch0.8mm
U2: ISP; Pin_Header_Straight_2x03
Y1: 16MHz; HC49SM

Connections:
/COL1: D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.32 ((ICP3/CLK0/OC4A)PC7)
/COL2: D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), U1.18 ((OC0B/SCL/INT0)PD0)
/COL3: D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), U1.19 ((SDA/INT1)PD1)
/COL4: D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), U1.20 ((RXD/INT2)PD2)
/COL5: D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), U1.21 ((TXD/INT3)PD3)
/COL6: D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), U1.25 ((ICP2/ADC8)PD4)
/COL7: D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.22 ((XCK1/~CTS~)PD5)
/COL8: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), U1.27 ((T0/OC4D/ADC10)PD7)
/COL9: D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), U1.1 ((INT6/AIN0)PE6)
/COL10: D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), U1.41 ((ADC0)PF0)
/COL11: D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), U1.40 ((ADC1)PF1)
/COL12: D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), U1.39 ((ADC4/TCK)PF4)
/COL13: D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), U1.38 ((ADC5/TMS)PF5)
/COL14: D64.1 (K), D65.1 (K), D66.1 (K), U1.37 ((ADC6/TDO)PF6)
/ROW1: SW2.1, SW7.1, SW12.1, SW18.1, SW22.1, SW27.1, SW32.1, SW37.1, SW42.1, SW47.1, SW52.1, SW56.1, SW60.1, SW64.1, U1.28 ((ADC11/PCINT4)PB4)
/ROW2: SW3.1, SW8.1, SW13.1, SW19.1, SW23.1, SW28.1, SW33.1, SW38.1, SW43.1, SW48.1, SW53.1, SW57.1, SW61.1, SW65.1, SW77.1, U1.29 ((ADC12/OC1A/~OC4B~/PCINT12)PB5)
/ROW3: SW4.1, SW9.1, SW14.1, SW20.1, SW24.1, SW29.1, SW34.1, SW39.1, SW44.1, SW49.1, SW54.1, SW58.1, SW62.1, SW66.1, U1.30 ((ADC13/OC1B/OC4B/PCINT13)PB6)
/ROW4: SW5.1, SW10.1, SW15.1, SW21.1, SW25.1, SW30.1, SW35.1, SW40.1, SW45.1, SW50.1, SW55.1, SW59.1, SW63.1, SW76.1, U1.12 ((OC0A/OC1C/~RTS~/PCINT7)PB7)
/ROW5: SW6.1, SW11.1, SW16.1, SW17.1, SW26.1, SW31.1, SW36.1, SW41.1, SW46.1, SW51.1, SW67.1, SW68.1, SW69.1, SW70.1, SW71.1, SW72.1, SW73.1, SW74.1, SW75.1, U1.31 ((OC3A/~OC4A~)PC6)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C8.2, D1.1 (K), P1.5 (GND), SW1.1, U1.15 (GND), U1.23 (GND), U1.33 ((~HWB~)PE2), U1.35 (GND), U1.43 (GND), U2.6 (GND)
unnamed: C1.1, U1.17 (XTAL1), Y1.1
unnamed: C2.2, C4.1, C5.1, C6.1, C8.1, P1.1 (VCC), R1.2, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC), U2.2 (VCC)
unnamed: C3.1, U1.16 (XTAL2), Y1.2
unnamed: C7.1, U1.6 (UCAP)
unnamed: C7.2, U1.5 (UGND)
unnamed: D1.2 (A), R4.1
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2, SW67.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2, SW68.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2, SW69.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2, SW70.2, SW71.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2, SW72.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2, SW73.2
unnamed: D42.2 (A), SW42.2
unnamed: D43.2 (A), SW43.2
unnamed: D44.2 (A), SW44.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2, SW74.2
unnamed: D47.2 (A), SW47.2
unnamed: D48.2 (A), SW48.2
unnamed: D49.2 (A), SW49.2
unnamed: D50.2 (A), SW50.2
unnamed: D51.2 (A), SW51.2, SW75.2
unnamed: D52.2 (A), SW52.2
unnamed: D53.2 (A), SW53.2
unnamed: D54.2 (A), SW54.2
unnamed: D55.2 (A), SW55.2
unnamed: D56.2 (A), SW56.2
unnamed: D57.2 (A), SW57.2
unnamed: D58.2 (A), SW58.2
unnamed: D59.2 (A), SW59.2, SW76.2
unnamed: D60.2 (A), SW60.2
unnamed: D61.2 (A), SW61.2
unnamed: D62.2 (A), SW62.2
unnamed: D63.2 (A), SW63.2
unnamed: D64.2 (A), SW64.2
unnamed: D65.2 (A), SW65.2, SW77.2
unnamed: D66.2 (A), SW66.2
unnamed: P1.2 (D-), R2.2
unnamed: P1.3 (D+), R3.2
unnamed 95: U1.8 ((SS/PCINT0)PB0); also elsewhere on the board
unnamed 96: U1.36 ((ADC7/TDI)PF7); also elsewhere on the board
unnamed: R1.1, SW1.2, U1.13 (RESET), U2.5 (RST)
unnamed: R2.1, U1.3 (D-)
unnamed: R3.1, U1.4 (D+)
unnamed: R4.2, U1.26 ((T1/~OC4D~/ADC9)PD6)
unnamed: U1.9 ((SCLK/PCINT1)PB1), U2.3 (SCK)
unnamed: U1.10 ((PDI/MOSI/PCINT2)PB2), U2.4 (MOSI)
unnamed: U1.11 ((PDO/MISO/PCINT3)PB3), U2.1 (MISO)

Board: 2 copper layers, 285.0 x 97.5 mm, 166 parts (84 on the bottom side), 102 nets.

Other parts of the board:
HOLE: VAL**; PKRHC
HOLE#2, HOLE#3: VAL**; PKRHSL
HOLE#4, HOLE#5, HOLE#6: VAL**; PKRH
PB0 PF7: CONN_01X02; Pin_Header_Straight_1x02_Pitch2.54mm

Their connections:
unnamed 95: PB0 PF7.1; also elsewhere on the board
unnamed 96: PB0 PF7.2; also elsewhere on the board

## Commit log

2016-07-16 Initial commit - r1 schematic, must fix bottom row
2017-01-12 Last commit before moving everything, roll back to this if you need it
2017-01-22 Finished?? No name on board
